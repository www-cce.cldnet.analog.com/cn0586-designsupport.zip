# Allegro board 08_081443a1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LDAC_N_DAC: length 46.9
  TOP w0.249: v1(80.75,67.59) 81.17,67.59 81.42,67.34 81.42,64.9 U1.10
  TOP w0.305: 56.33,52.69 R57.2 U3.14 62.03,52.69 65.42,49.31 LDAC_N.1 v1(73.44,49.31)
  TOP w0.5: v1(80.75,67.59) R3.2
  BOTTOM w0.3: v1(73.44,49.31) 73.44,65.48 75.13,67.18 77.47,67.18 77.88,66.76 79.92,66.76 v1(80.75,67.59)
REF: length 7.5
  TOP w1.001: J1.1 65.03,40.89 65.09,40.94 JP1.3
SCL: length 22.1
  TOP w0.305: U5.6 6.81,67.17 3.14,70.84 P17.10
SCLK: length 68.3
  TOP w0.305: P11.4 12.55,58.53 v2(13.3,57.78) 13.31,57.77 U3.3 R43.1 54.83,57.77
  BOTTOM w0.305: P17.6 v2(13.3,57.78)
SCLK_DAC: length 37.6
  TOP w0.305: U1.8 82.72,68.16 81.71,69.17 76.65,69.17 73.64,66.16 73.64,61.35 72.44,60.14 SCLK.1 67.82,59.14 64.61,59.14 63.24,57.77 U3.18 R43.2 56.33,57.77
SDA: length 18.9
  TOP w0.305: P17.9 5.62,76.12 5.62,71.18 8.36,68.44 U5.5
SDIN: length 73.5
  TOP w0.305: 54.83,56.5 R53.1 U3.4 v2(49.1,56.5) ; v2(47.7,55.12) 21.53,55.12 19.87,53.45 v2(18.36,53.45) P11.2
  BOTTOM w0.305: v2(47.7,55.12) 49.08,56.5 v2(49.1,56.5) ; P17.4 18.38,53.48 v2(18.36,53.45)
SDIN_DAC: length 37.6
  TOP w0.305: 56.33,56.5 R53.2 U3.17 63.78,56.5 64.61,57.33 SDIN.1 73.04,57.33 74.95,59.24 74.95,65.44 78.08,68.57 81.36,68.57 82.07,67.86 82.07,64.9 U1.9
SDO: length 70.1
  TOP w0.305: 54.83,55.23 R55.1 U3.5 50.52,55.24 48.71,55.24 47.96,55.99 v2(15.82,55.99) P11.3
  BOTTOM w0.305: P17.5 15.84,56.02 v2(15.82,55.99)
SDO_DAC: length 29.2
  TOP w0.305: U1.16 82.07,59.11 82.07,56.71 81.74,56.39 80.08,54.72 SDO.1 66.42,54.72 65.91,55.23 U3.16 R55.2 56.33,55.23
SYNC_N: length 70.9
  TOP w0.3: R27.1 R28.1
  TOP w0.305: P11.1 19.75,50.91 22.8,53.97 v2(23.69,53.97) v1(44.65,53.97) ; R7.2 U3.6 R56.1 54.83,53.96 ; R28.1 v2(23.72,71.4)
  TOP w0.381: v1(44.65,53.97) 44.66,53.96 R7.2
  BOTTOM w0.305: v2(23.69,53.97) 23.72,54 v2(23.72,71.4)
SYNC_N_DAC: length 48.7
  TOP w0.249: v1(82.15,69.99) 83.37,68.76 U1.7
  TOP w0.305: v1(72.04,52.12) SYNC_N.1 63.97,53.96 U3.15 R56.2 56.33,53.96
  TOP w0.5: R4.2 v1(82.15,69.99)
  BOTTOM w0.3: v1(72.04,52.12) 72.04,66.48 74.55,68.99 81.15,68.99 v1(82.15,69.99)
TMP: length 38.7
  TOP w0.249: v1(126.5,63.19) 126.5,72.94 125.45,74 A1.5
  TOP w0.399: R33.1 JP4.3
  BOTTOM w0.254: v1(126.5,63.19) 121.66,58.34 118.12,58.34 110.76,50.98 JP4.3
U4_RFB2: length 9
  TOP w0.399: S1.1 113.66,8.11 114.8,6.97 120.4,6.97 120.8,7.37 R72.2
U6_EN: length 22.9
  TOP w0.3: U6.1 113.83,23.01 113.52,23.32 v1(113.52,23.77)
  TOP w0.813: R39.2 108.35,20.55 v1(108.35,19.64)
  BOTTOM w0.8: v1(108.35,19.64) 108.35,21.69 110.42,23.76 113.5,23.76 v1(113.52,23.77)
  BOTTOM w0.813: R45.1 114.58,23.77 v1(113.52,23.77)
  BOTTOM w1.001: v1(108.35,19.64) 113.66,14.33 S1.4
UNNAMED_2_AD57X4R_I19_REFINREFO: length 25.7
  TOP w0.351: 82.72,55.96 82.72,59.11 U1.17
  TOP w1.001: 73.42,39.3 JP1.2 73.42,42.47 82.72,51.77 82.72,55.62 ; C5.2 82.72,55.62 ; 82.72,55.62 82.72,55.96
  TOP w1.016: TP_REF.1 73.42,39.3
UNNAMED_2_AD57X4R_I19_VOUTA: length 13.9
  TOP w0.305: U1.3 85.97,67.34 TP_A.1 90.51,69.2 JP7.2
UNNAMED_2_AD57X4R_I19_VOUTB: length 18.5
  TOP w0.305: JP8.2 91.35,72.41 TP_B.1 85.32,70.74 U1.4
UNNAMED_2_AD57X4R_I19_VOUTC: length 13.3
  TOP w0.305: JP9.2 TP_C.1 88.98,53.35 86.62,55.71 U1.23
UNNAMED_2_AD57X4R_I19_VOUTD: length 21.5
  TOP w0.305: U1.22 85.97,49.66 TP_D.1 93.92,45.12 JP10.2
UNNAMED_2_ADR441_I50_VOUT: length 28.9
  TOP w0.5: U2.6 87.9,19.66 C9.2
  TOP w1.001: C9.2 v1(87.99,21.82)
  BOTTOM w1.001: v1(87.99,21.82) 82.56,27.24 82.56,34.34 JP1.1
UNNAMED_2_CN3PJMPRSHRT_I28_S1: length 3
  TOP w0.5: JP3.1 R12.1
UNNAMED_2_CN3PJMPRSHRT_I28_S3: length 3.2
  TOP w0.5: R9.1 JP3.3
UNNAMED_2_CN8PA_I284_N2: length 2.8
  TOP w1.016: P14.2 14.8,27.96 14.8,30.55 R26.1
UNNAMED_2_CN10P_I292_N2: length 3.4
  TOP w0.376: R28.2 22.7,73.88 23.46,74.64 P17.2
UNNAMED_2_CN10P_I292_N3: length 3.1
  TOP w0.3: R27.2 21.05,73.84 20.92,73.97 P17.3
UNNAMED_2_CN12PV3_I158_VCC1: length 5.8
  TOP w1.001: R1.1 P11.6 P11.12
UNNAMED_2_DIOLED_I327_P: length 1.7
  TOP w0.508: DS1.A R59.2
UNNAMED_2_DIOLED_I330_P: length 1.6
  TOP w0.381: R62.2 DS2.A
UNNAMED_2_DIOLED_I335_P: length 1.5
  TOP w0.762: DS3.A R65.2
UNNAMED_2_DIOLED_I337_P: length 1.6
  TOP w0.508: DS4.A R66.2
UNNAMED_2_IC24XX64_I297_A0: length 3
  TOP w0.399: R25.2 R41.2
  TOP w0.5: R25.2 23.45,63.54 23.46,63.55 U5.1
UNNAMED_4_CAP_I184_N2: length 7.8
  TOP w1.001: C35.2 122.17,27.39 122.21,27.35 123.51,27.35 ; 123.51,27.35 C51.1 ; 123.51,27.35 123.51,26.97 124.3,26.18 D5.C 123.9,25.19 121.5,25.19 D3.A
UNNAMED_4_CAP_I188_N1: length 4.3
  TOP w0.762: C42.1 135.79,22.47 R54.2 R69.1
UNNAMED_4_CAP_I188_N2: length 9.6
  TOP w1.001: 130.25,22.02 130.35,21.92 C52.1 ; 130.25,22.02 R37.2 128.79,22.08 128.79,24.09 129.04,24.34 D9.C ; 130.25,22.02 132.78,22.02 132.95,22.19 C42.2
UNNAMED_4_CAP_I194_N1: length 2.5
  TOP w0.249: U6.11 120.91,20.51 C32.1
UNNAMED_4_CAP_I196_N1: length 2.4
  TOP w0.249: U6.5 113.37,21.01 112.75,20.39 C39.1
UNNAMED_4_CAP_I198_N1: length 1.6
  TOP w0.5: R35.2 110.5,18.69 110.55,18.64 C37.1
UNNAMED_4_CAP_I204_N2: length 7.8
  TOP w1.001: D6.A 127.34,44.69 125.75,44.69 ; 123.25,44.03 D4.C 123.25,44.03 ; 123.25,44.03 123.9,44.69 125.75,44.69 ; 123.25,44.03 121.89,44.03 C36.2 ; 125.75,44.69 C40.1 125.75,44.69
UNNAMED_4_CAP_I207_N2: length 5.1
  TOP w1.001: D8.A 125.74,39.18 D7.C 125.75,39.8 C40.2
UNNAMED_4_CAP_I211_N1: length 5.6
  TOP w1.001: D8.C 129.39,37.99 R42.1 130.75,38.03 C43.1
UNNAMED_4_CAP_I211_N2: length 9.2
  TOP w1.001: 133.54,43.79 C43.2 ; 133.54,43.79 C44.1 ; 133.54,43.79 132.45,43.79 131.65,42.99 R38.2 130.5,45.28 D6.C
UNNAMED_4_CAP_I220_N1: length 2.6
  TOP w0.249: U4.5 112.73,36.76
  TOP w0.3: 112.73,36.76 112.57,36.59 C41.1
UNNAMED_4_CAP_I222_N1: length 1.6
  TOP w0.5: R36.2 113.7,32.94 C38.1
UNNAMED_4_CAP_I227_N1: length 3.4
  TOP w0.249: C34.1 121.15,36.26 U4.11
UNNAMED_4_CAP_I249_N2: length 5.3
  TOP w1.001: 129.04,27.39 D9.A 129.04,27.39 ; 129.04,27.39 129.13,27.31 131.32,27.31 D10.C ; 129.04,27.39 129.01,27.35 126.58,27.35 126.55,27.39 C51.2
UNNAMED_4_DIOSCHOTTKY_I186_P: length 2.8
  TOP w0.5: D5.A 126.85,23.64 126.95,23.54 R37.1
UNNAMED_4_DIOSCHOTTKY_I203_P: length 1.4
  TOP w0.508: 123.25,40.12 R52.1 D4.A
UNNAMED_4_DIOSCHOTTKY_I209_P: length 3.5
  TOP w1.001: R38.1 128.6,40.9 128.6,40.89 D7.A
UNNAMED_4_DIOSCHOTTKY_I252_P: length 2.3
  TOP w0.762: D10.A 131.7,25.03 R54.1
UNNAMED_4_ICLTC8365_I179_FBX: length 11.2
  TOP w0.229: 119.39,19.25 119.14,19.51 U6.9
  TOP w0.381: 119.39,19.25 119.39,18.36 R50.1 119.14,18 R51.1 121.39,15.75 R44.2
UNNAMED_4_ICLTC8365_I179_RT: length 2.9
  TOP w0.203: 120.55,19.06 120.79,18.81 R34.1
  TOP w0.249: 120.55,19.06 120.55,19.22 119.76,20.01 U6.10
UNNAMED_4_ICLTC8365_I179_VC: length 2.4
  TOP w0.249: R35.1 112.19,18.79 112.92,19.51 U6.8
UNNAMED_4_ICLTC8365_I200_EN: length 10
  TOP w0.3: 113.34,39.12 113.71,38.76 U4.1
  TOP w0.508: v1(107.96,38.62) R48.2
  TOP w0.8: v1(113.15,40.36) 113.15,39.31 113.34,39.12
  BOTTOM w0.508: v1(113.15,40.36) 113.12,40.34 R49.1 108.56,39.27 107.96,38.67 v1(107.96,38.62)
UNNAMED_4_ICLTC8365_I200_FBX: length 4.7
  TOP w1.001: 119.4,33.79 120.3,33.79 120.7,33.39 R46.2 R47.1
UNNAMED_4_ICLTC8365_I200_RT: length 3.3
  TOP w0.203: R73.1 121.55,35.06
  TOP w0.249: 121.55,35.06 120.8,35.06 120.1,35.76 U4.10
  TOP w0.254: 121.55,35.06 121.55,35.06
UNNAMED_4_ICLTC8365_I200_VC: length 2.4
  TOP w0.249: U4.8 113.75,35.26 113.13,34.64 R36.1
UNNAMED_4_IND_I183_N2: length 2.3
  TOP w0.8: L2.2 L5.1
UNNAMED_4_IND_I205_N1: length 2.4
  TOP w0.8: L4.2 L3.1
UNNAMED_4_RES_I219_N2: length 1.8
  TOP w0.508: R71.1 117.81,32.48 R40.2
UNNAMED_4_RES_I223_N2: length 55.9
  TOP w0.254: R72.1 137.7,10.23 141.86,14.38 141.86,26.48 138.15,30.19 R47.2
UNNAMED_4_RES_I233_N2: length 1.6
  TOP w0.381: R50.2 117.34,16.49 R70.1
UNNAMED_5_ADHV4702_I35_COMP: length 47.2
  TOP w0.376: A1.11 112.5,74 110.63,75.87 110.63,87.17 117.29,93.84 130.94,93.84 134.21,90.58
  TOP w0.381: C21.2 134.38,90.41 134.21,90.58
UNNAMED_5_ADHV4702_I35_IN: length 65
  TOP w0.381: R29.2 109.81,73.42 108.76,74.47 108.76,86.63 116.98,94.86 131.23,94.86 132.79,93.3 R17.1 ; R29.2 109.89,72.3 A1.12 ; R29.2 109.81,70.77 D1.1 D2.2
UNNAMED_5_ADHV4702_I35_IN_1: length 20.8
  TOP w0.376: A1.2 120.45,69.5 119.7,68.75 118.24,68.75 115.59,66.09 C15.1 115.54,64.14 R15.1 R14.2 111.22,65.84 108.99,68.07 106.93,68.07
UNNAMED_5_ADHV4702_I35_RADJ: length 4.8
  TOP w0.376: A1.9 113.98,77.25 R19.1
UNNAMED_5_ADHV4702_I35_VCC: length 15.9
  TOP w1.524: JP5.5 JP5.3 JP5.1
  L3_PWR w0.508: JP5.1 138.12,55.93 ; JP5.1 135.71,55.93 ; JP5.1 136.92,54.72 ; 139.46,54.72 JP5.3 ; JP5.3 138.25,55.93 ; JP5.3 140.66,55.93 ; 140.79,55.93 JP5.5 ; JP5.5 142,54.72 ; JP5.5 143.2,55.93
  vias: v1(125.54,88.55) v1(125.54,87.25) v1(125.54,85.94) v1(125.54,84.64)
UNNAMED_5_ADHV4702_I35_VEE: length 58.9
  TOP w1.27: C19.2 C22.1 ; 124.22,69.6 124.22,68.76
  TOP w1.501: 124.22,68.76 C22.1 124.24,66.17 124.24,60.06
  TOP w1.524: JP6.1 JP6.3 JP6.5 144.02,37.64 144.92,38.54 144.92,43.12
  TOP w3: 124.24,60.06 124.22,60.04 124.22,56.09 128.76,51.54 140.27,51.54 144.92,46.89 144.92,43.12
UNNAMED_5_CAP_I29_N1: length 1.9
  TOP w1.001: R20.1 C21.1
UNNAMED_5_CAP_I34_N2: length 8.3
  TOP w0.376: R13.2 R16.1 110.18,62.43 R15.2 115.54,62.43 C15.2
UNNAMED_5_CAP_I38_N1: length 6.6
  TOP w0.762: R17.2 R18.1 R67.1 146.38,88.83 C16.1
UNNAMED_5_RES_I25_N1: length 1.9
  TOP w0.376: R14.1 R11.2
UNNAMED_5_RES_I46_N1: length 1.3
  TOP w0.381: R29.1 R30.2
UNNAMED_5_RES_I48_N2: length 1.9
  TOP w0.381: R32.1 103.54,74.04 R31.2
VOA: length 40.4
  TOP w0.305: v1(99.94,70.21) 99.93,70.2 JP7.3
  TOP w0.381: P5.1 R60.1
  TOP w0.762: C4.1 R60.1
  BOTTOM w0.381: P5.1 99.94,90.43 v1(99.94,70.21)
VOB: length 37.4
  TOP w0.305: JP8.3 v1(98.93,73.41)
  TOP w0.381: P5.2 R63.1
  TOP w0.762: R63.1 C17.1
  BOTTOM w0.381: P5.2 98.93,87.63 v1(98.93,73.41)
VOC: length 56.6
  TOP w0.305: v1(97.93,54.35) 97.93,54.35 JP9.3
  TOP w0.381: P5.3 R61.1
  TOP w0.762: R61.1 C6.1
  BOTTOM w0.381: v1(97.93,54.35) 97.93,84.82 P5.3
VOD: length 63
  TOP w0.305: JP10.3 96.32,47.73 v1(96.93,48.33)
  TOP w0.381: R64.1 P5.4
  TOP w0.762: R64.1 C18.1
  BOTTOM w0.381: v1(96.93,48.33) 96.93,82.01 P5.4
VOUT_HV: length 40.8
  TOP w1.27: JP11.1 R21.2
  TOP w1.501: J2.1 HVOUT_F.1
  TOP w3: R22.2 150.42,70.1 147.94,67.62 P3.1 P3.2

## Copper pours and planes (outline as drawn)
15V_FLT on TOP (solid shape): 107.9,39.94 106,39.94 106,41.24 107.9,41.24
15V_FLT on TOP (solid shape): 109.4,21.79 107.75,21.79 107.5,22.04 107.5,23.09 109.4,23.09
15V_FLT on TOP: 99.96,42.97 103.75,42.97 106.16,45.39 109.15,45.39 109.55,44.99 109.55,40.59 111.2,38.94 112.37,38.94 112.72,38.59 112.86,38.59 113.17,38.28 114.82,38.28 114.95,38.15 114.95,37.39 114.82,37.26 112.67,37.26 112.5,37.44 109.9,37.44 109.34,37.99 109.34,39.39 108.81,39.93 102.37,39.93 97.55,35.1 97.55,31.39 107.65,31.39 109.84,29.19 110.94,29.19 111.25,28.89 111.25,25.89 109.99,24.64 109.99,23.44 110.94,22.49 110.94,22.48 112.85,22.48 113.1,22.22 115.01,22.22 115.01,21.84 113.07,21.84 112.72,21.49 107.94,21.49 107.35,22.09 107.35,22.99 102.6,27.73 80.66,27.73 80.4,27.99 80.4,33.45 82.56,35.61 92.6,35.61
15V_HV on TOP: 71.89,31.54 79.13,31.54 79.39,31.29 79.39,24.43 79.13,24.18 72.15,24.18 71.89,24.43
AVDD on TOP: 88.45,57.91 88.82,57.52 89.34,57.37 90.05,57.65 90.36,58.35 90.36,58.47 93.34,58.47 93.63,58.19 93.75,58.19 94.11,57.83 94.11,55.03 93.67,54.59 91.88,54.59 91.26,55.04 90.51,55.2 89.79,55.05 89.18,54.64 89.09,54.6 89,54.63 87.32,56.31 87.32,57.78 87.7,58.16 87.7,59.94 88.21,59.94 88.21,57.91
AVDD on TOP: 76.3,23.17 75.85,23.62 72.64,23.62 72.1,23.08 72.1,4.56 72.11,4.54 78.59,4.54 78.84,4.8 78.84,9.12 76.3,11.66
AVDD on L3_PWR: 68.59,52.5 68.59,21.89 69.75,20.74 74.85,20.74 76.01,21.9 76.01,25.37 96.28,45.64 96.28,59.1 96.02,59.36 90.89,59.36 84.29,52.75 68.85,52.75
AVSS on TOP: 84.43,16.74 84.69,16.99 88.75,16.99 89,16.74 89,4.8 88.75,4.54 82.15,4.54 81.89,4.8 81.89,9.12 84.43,11.66
AVSS on TOP: 93.87,63.31 93.87,67.74 93.36,68.25 88.53,68.25 87.13,66.85 87.13,63.8 86.88,63.55 81.18,63.55 81.15,63.59 79.95,63.59 77.94,65.59 76.15,65.59 75.54,64.99 75.54,58.79 75.75,58.59 78.75,58.59 78.95,58.79 78.95,59.79 79.66,60.5 87.13,60.5 87.18,60.55 92.51,60.55 93.75,61.79 93.75,63.19
AVSS on BOTTOM: 93.8,67.81 93.36,68.25 88.53,68.25 87.13,66.85 87.13,63.8 86.88,63.55 81.18,63.55 81.15,63.59 79.95,63.59 77.94,65.59 76.15,65.59 75.54,64.99 75.54,58.79 75.75,58.59 78.75,58.59 78.95,58.79 78.95,59.79 79.66,60.5 87.13,60.5 87.18,60.55 92.51,60.55 93.8,61.84
AVSS on L3_PWR: 77.48,26.21 96.66,45.39 96.66,59.36 96.28,59.74 86.15,59.74 85.99,59.59 78.95,59.59 78.75,59.79 78.75,63.39 79.34,63.99 84.91,63.99 85.86,64.95 91.83,64.95 92.21,65.33 92.21,69.26 92.47,69.52 99.33,69.52 103.9,64.95 103.9,40.05 85.75,21.9 85.75,18.59 88.54,15.8 99.1,15.8 117.8,34.49 117.8,43.72 122.01,47.93 139.47,47.93 141.47,45.93 141.47,39.1 139.67,39.1 139.27,39.5 139.27,43.12 138.86,43.52 133.89,43.52 131.64,41.27 131.64,30.86 130.26,29.47 122.41,29.47 121.17,28.23 121.17,13.05 121.21,13.02 121.21,10.95 117.8,7.54 77.74,7.54 77.48,7.8
DVCC_DAC on L3_PWR: 87.14,22.66 87.14,19.04 90,16.18 98.82,16.18 117.11,34.47 117.11,63.87 98.25,82.73 68.85,82.73 63.15,77.03 63.15,58.83 67.59,54.39 77.94,54.39 79.75,56.19 79.75,57.19 78.55,58.39 74.95,58.39 73.35,59.99 73.35,65.39 73.55,65.59 75.54,65.59 76.55,64.59 79.55,64.59 80.28,65.33 91.45,65.33 91.83,65.71 91.83,69.52 92.21,69.9 99.58,69.9 104.28,65.2 104.28,39.8
GND on TOP: 58.8,99.5 167.95,99.5 167.95,0.68 58.82,0.68 58.82,33.57 58.8,45.13 ; 2 cut-outs
GND on BOTTOM: 58.8,99.5 167.94,99.5 167.94,0.5 75.43,0.5 75.43,0.5 58.85,0.5 58.85,33.54 58.75,33.63 58.8,45.1
GND on L2_GND: 58.81,99.5 167.94,99.5 167.94,0.5 75.43,0.5 75.43,0.5 58.85,0.5 58.85,98.19 58.8,98.26 58.8,99.49
GND on L3_PWR: 58.81,99.5 167.95,99.5 167.95,0.5 68.59,0.5 68.59,0.5 58.85,0.5 58.85,98.19 58.8,98.26 58.8,99.49
GND_ISO on TOP, BOTTOM, L2_GND, L3_PWR: 52.37,79 52.37,22.79 0.49,22.79 0.49,79
VCCHV_EXT on BOTTOM: 141.17,58.8 141.17,58.04 141.55,57.66 142.44,57.66 143.2,56.89 143.2,47.5 146.63,44.07 146.63,38.73 149.68,38.73 149.68,44.96 146.25,48.38 146.25,58.04 144.98,59.31 141.68,59.31
VCCHV_LT8365 on BOTTOM: 132.79,30.6 123.52,30.6 122.88,31.24 122.88,32.13 123.52,32.76 128.98,32.76 132.15,35.94 132.15,56.89 134.56,59.31 137.36,59.31 137.74,58.93 137.74,58.04 137.36,57.66 136.6,57.66 135.71,56.77 135.71,33.53
VCCISO_EXT on L3_PWR: 48.76,30.24 10.63,30.24 10.63,33.25 41.94,33.25 41.94,58.99 41.94,58.99 39.94,60.99 9.34,60.99 8.54,61.79 8.54,63.19 10.74,65.39 28.69,65.39 28.69,68.57 32.31,72.18 39.73,72.18 48.76,63.15
VSSHV_EXT on BOTTOM: 141.68,41.02 141.68,39.37 142.82,39.37 143.58,38.61 143.58,15.75 144.72,14.6 149.68,14.6 149.68,17.52 146.38,20.83 146.38,36.7 145.61,37.46 145.61,39.75 144.34,41.02
VSSHV_LT8365 on L3_PWR: 140.27,30.02 138.97,30.02 138.06,30.92 138.06,41.27 134.06,41.27 133.17,40.38 133.17,30.73 131.31,28.87 122.41,28.87 121.55,28.01 121.55,21.7 122.01,21.24 123.81,21.24 126.26,18.8 126.26,17.53 126.46,17.33 127.66,17.33 129.94,19.61 138.7,19.61 138.7,19.67 141.67,22.65 141.67,28.62
3P3V_EXT on TOP: 94.47,23.21 93.92,23.75 92.02,23.75 90.53,22.26 90.53,3.27 90.78,3.02 94.21,3.02 94.47,3.27
UNNAMED_4_CAP_I204_N1 on TOP: 114.85,44.79 118.05,44.79 118.65,44.19 118.65,41.49 119.34,40.79 119.34,37.74 119.2,37.59 117.93,37.59 117.85,37.67 117.85,40.69 116.95,41.59 114.95,41.59 114.85,41.69
UNNAMED_4_CAP_I211_N2 on TOP (solid shape): 131.55,45.79 132.54,44.79 134.65,44.79 134.74,44.69 134.74,39.79 134.55,39.59 133.05,39.59 132.84,39.79 132.84,42.09 132.54,42.39 130.14,42.39 129.95,42.59 129.95,44.69 129.55,45.09 129.55,45.79 129.65,45.89 131.55,45.89
UNNAMED_4_ICLTC8365_I179_SW1 on TOP: 117.94,21.99 118.05,21.89 119.55,21.89 119.65,21.99 119.65,28.29 118.95,28.99 116.45,28.99 116.25,28.79 116.25,25.99 116.85,25.39 117.44,25.39 117.94,24.89
UNNAMED_4_ICLTC8365_I200_FBX on TOP (solid shape): 121.15,33.59 121.15,29.99 120.94,29.79 120.14,29.79 119.75,30.19 119.75,32.99 119.55,33.19 119.15,33.19 118.95,33.39 118.95,34.39 118.04,35.29 119.44,35.29
UNNAMED_4_IND_I183_N2 on TOP (solid shape): 115.05,28.79 115.05,25.99 114.95,25.89 112.45,25.89 112.35,25.99 112.35,28.89 114.95,28.89
UNNAMED_4_IND_I205_N1 on TOP (solid shape): 113.55,44.49 113.55,41.79 113.45,41.69 110.55,41.69 110.55,44.59 110.75,44.79 113.25,44.79
UNNAMED_5_ADHV4702_I35_OUT on TOP: 136.25,77.72 136.25,83.56 133.58,83.56 132.95,82.93 132.95,78.59 131.95,77.59 126.34,77.59 125.75,76.99 125.75,76.53 125.21,75.99 123.61,75.99 123.41,75.79 123.41,75.59 123.61,75.39 126.14,75.39 126.15,75.39 127.94,75.39 128.35,74.99 128.35,73.46 129.42,72.38 130.23,72.38 132.14,74.29 141.55,74.29 141.55,77.72
UNNAMED_5_ADHV4702_I35_VCC on TOP: 122,76.88 122.89,76.88 123.58,77.58 123.58,81.81 125.02,83.25 126.02,83.25 126.62,83.85 126.62,88.84 126.02,89.44 122.8,89.44 122,88.64
UNNAMED_5_ADHV4702_I35_VCC on L3_PWR: 144.34,54.23 144.34,87 142.28,89.07 124.82,89.07 124.82,84.05 133.45,84.05 135.01,82.48 135.01,64.2 133.42,62.61 133.42,54.23 135.07,52.58 142.69,52.58
UNNAMED_5_ADHV4702_I35_VEE on TOP: 123.46,71.8 123.33,71.93 123.33,72.31 123.58,72.57 124.6,72.57 124.98,72.18 124.98,65.33 124.85,65.2 123.58,65.2 123.46,65.33
VOUT_HV on TOP: 143.84,74.29 152.98,74.29 153.36,74.67 161.62,74.67 162.5,75.56 162.5,76.58 161.74,77.34 153.23,77.34 152.85,77.72 143.84,77.72

## Text on the board
Ref Des/Silkscreen Bottom: 08-081443 REV A Z | SECONDARY SIDE
User.Comments: A | B | JP2 POS A | JP3 POS A | JP4 POS A | JP5 POS A | JP6 POS A | JP7 POS A | JP8 POS A | JP9 POS A | JP10 POS A | JP11 SHORT | JP12 SHORT | JP1 POS A | 5.    JUMPER POSITIONS: | S1 POS B
Ref Des/Assembly Top: A | B | C | 2 | +
Ref Des/Silkscreen Top: REF | B | AVDD | A | GND | AVSS | DVCC | PRIMARY SIDE | C | VCCHV_EXT | VSSHV_EXT | VOUTHV | CLR_N | LDAC_N | VCC_ISO | UCON_PWR | SDO | SCLK | SDIN | SYNC_N | DIGI1 | POWER | ANALOG IN | DIGI0 | DAC_PWR | ON-BOARD_HV_PWR | HV_DRIVER_PWR | WHEN POWERED ON | SAFETY WARNING: | DO NOT CHANGE BOARD SETTINGS | EVAL-CN0586-ARDZ | +
PAGE_OUTLINE: 28FEB24 | EVAL-CN0586-ARDZ
DIMENSION: - | " " | (REF) | DIA MAX
User.10: L2 GND | 08-      -07
User.11: 08-      -08 | L3 PWR
User.12: FAB NOTES REVISION: 2ND NOVEMBER 2022 | 12.  DRILL SIZES ARE FINISHED HOLE SIZES. ALL HOLES SHALL BE LOCATED WITHIN 0.005 INCHES DTP,UNLESS SPECIFIED. | 8.   IMPEDANCE REQUIREMENTS: IF NO STACKUP IS DEFINED, THE VENDOR IS ALLOWED TO ADJUST THE DIELECTRIC | 13.  PLATING SPECIFICATION: | 9.   FILLET OPTIONS TO ENHANCE RELIABILITY AT PAD JUNCTIONS WHERE SPACING PERMITS. | 10.  THIEVING: | 11.  LAYER TO LAYER REGISTRATION SHALL BE WITHIN 0.003 INCHES. | 14.  SURFACE FINISH: | 15.  SOLDERMASK: | 1.   DIMENSIONS ARE IN INCHES (EXCEPT WHERE NOTED). | ALL DOCUMENTS & SPECIFICATIONS REFERRED TO BELOW SHOULD BE THE LATEST REVISIONS. | 2.  BOARD MATERIAL:(USE CHECKED ITEMS) | 3.   ALL LAMINATES & BONDING MATERIALS SHOULD BE SELECTED FROM IPC-4101 OR IPC-4103,(TG>170 DEGC TD>300 DEGC) | 4.   REFER TO IPC-6010 SERIES, CLASS 2 FOR FABRICATION. | 5.   REFER TO LAMINATION DIAGRAM FOR OVERALL BOARD THICKNESS, TOLERANCE APPLIES AFTER ALL LAMINATION AND PLATING | 6.   BOW & TWIST NOT TO EXCEED 0.0075 INCHES (0.75%) PER LINEAR INCH AND SHOULD BE MEASURED PER IPC-TM-650, METHOD 2.4.22. | 7.   ACCEPTABILITY PER ADI SPECIFICATION TST00115. | 16.  APPLY SILKSCREEN TO BOTH SIDES USING A NON-CONDUCTIVE, EPOXY BASED INK PER ARTWORK. | ( ) FILLETS ALLOWED | (X) FILLETS NOT ALLOWED | ( ) VENDOR MAY ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS MAINTAINING A MINIMUM | (X) VENDOR MAY NOT ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS. | (X) LPI | ( ) OTHER_________ | COLOR | (X) GREEN | (X) WHITE | ( ) OTHER | HINDER PROPER SOLDER WICKING. BARREL RELIEF ON SOLDERMASK ALLOWED IN UNFILLED VIA IN PAD HOLES. | (X) REFER TO LAMINATION DIAGRAM FOR FINISHED COPPER WEIGHT/THICKNESS REQUIRMENTS | (X) IMMERSION GOLD (ENIG) 1.58-3.94 MICRO INCHES OVER 118-236 MICRO INCHES MIN. OF ELECTROLESS NICKEL PER IPC-4552 | ( ) OSP (ORGANIC SOLDERABILITY PRESERVATIVE) | ( ) IMMERSION SILVER | ( ) SOFT WIRE BONDABLE GOLD 30-50 MICRO INCHES OF SOFT WIRE | ( ) EDGE CONNECTOR FINGERS ARE TO BE PLATED WITH 100 MICRO-INCHES(.0001") OF LOW STRESS | THICKNESS & TRACE WIDTHS TO MEET THE IMPEDANCE REQUIREMENT. IF SPECIFIED, THE VENDOR MUST | TRACE WIDTH & SPACING THAT IMPACT THE REQUIREMENTS MUST HAVE WRITTEN APPROVAL FROM ADI. | MINIMUM BARREL PLATING OF 0.001 INCHES. PLATED HOLES SHALL NOT BE ROUGH OR IRREGULAR SO AS TO | SOLDERMASK OVER BARE COPPER OR BARE GOLD (BOTH SIDES) TO MEET IPC-SM-840. | IF PRESENT,DO NOT MODIFY SOLDERMASK DEFINED PADS (MASK OPENINGS LESS THAN COPPER PAD) WITHOUT APPROVAL. | MEET THE REQUIREMENTS LISTED IN THE IMPEDANCE TABLE. ANY ADJUSTMENT MADE TO THE DEFINED STACKUP, | PROCESSES. FINISHED THICKNESS MEASURED FROM TOP COPPER TO BOTTOM COPPER. | ( )  ISOLA 370HR OR S1000-2 OR IT180 OR EQUIVALENT | (X)  ISOLA-FR408HR OR EQUIVALENT | ( )  ISOLA IS410 | ( )  MEGTRON 6 | ( )  NELCO-4000-13 | ( )  ROGERS 4350B | ( ) ROGERS 3003 | ( ) ARLON 85N | ( ) EM370D | ( )  OTHER ________________________ | UL FLAMMABILITY RATING 94V-0. BOARD MATERIAL & CONSTRUCTION SHALL MEET THE REQUIREMENTS OF UL796/UL796F. | BONDABLE GOLD OVER 100-150 MICRO INCHES OF NICKEL | NICKEL UNDER 30 MICRO-INCHES (.0003') OF GOLD | 0.100 INCH CLEARANCE FROM ALL COPPER FEATURES, | THE STARTING COPPER WEIGHT/THICKNESS CAN VARY AS LONG AS THE FINISHED COPPER | WEIGHT/THICKNESS IS NOT LESS THAN THE SPECIFIED VALUE. | UNLESS OTHERWISE SPECIFIED | HOMOGENOUS MATERIALS IN THIS BOARD SHALL BE COMPLAINT WITH THE EU DIRECTIVE 2002/95/EC | WORKMANSHIP SHALL CONFORM TO IPC-A-600, CLASS 2. | 21.  INTENTIONAL SHORTS: | 17.  FINAL ELECTRICAL TEST TO BE PERFORMED USING PROVIDED IPC-D-356A NETLIST OR ODB++ FORMAT FILE. | 22.  PEMNUTS: | 23.  MANUFACTURER TO ETCH/STAMP WITH PERMANENT NON-CONDUCTIVE INK | ON SECONDARY SIDE UNLESS OTHERWISE SPECIFIED: | 18.  A TIME DOMAIN REFLECTOMETER REPORT (TDR) FOR EACH IMPEDANCE CONTROLLED LAYER & A CERTIFICATE | 19.  IF PRESENT, ALL BLIND/BURIED VIAS WITH AN ASPECT RATIO <1:1 TO BE PLATED SHUT WITH COPPER WHEN | 20.  FOR VIA FILL INFORMATION REFER TO DRILL CHART: | 24. PANELIZATION: | 25.  MINIMUM DESIGN LINE WIDTH IS .008 INCH. | 26.  MINIMUM DESIGN LINE SPACING IS .012 INCH. | IS ACCEPTABLE, ALL OTHER INSTANCES MUST BE REPORTED. | IF AN INTENTIONAL SHORT REPORT IS SUPPLIED AND DOES NOT MATCH THE FAB DATA THEN | THE PCB SHALL HAVE A VERIFICATION STAMP. | ( )  NON-CONDUCTIVE EPOXY FILL ALL 0.XXXX INCHES DRILLED VIAS | ( )  COPPER FILL ALL 0.XXXX INCHES DRILLED VIAS | ( ) PEMNUTS TO BE INSTALLED BY FABRICATOR | ( ) PEMNUTS NOT TO BE INSTALLED BY FABRICATOR | (X) NOT APPLICABLE | USED AS VIA-IN-PAD OR AS A STACKED VIA. BLIND/BURIED VIAS WITH AN ASPECT RATIO >1:1 TO BE FILLED | A. UL CODE-FLAMMABILITY RATING FOR THOSE APPROVED MATERIALS(IF APPLICABLE) | B. DATE CODE | C. LOT NUMBER | D. MANUFACTURER LOGO | BOARDS TO BE SHIPPED IN ARRAY AND KEPT INTACT | PANEL TO BE SUBJECTED TO CUSTOMERS APPROVAL | PANEL SOLDER PASTE STENCIL GERBER TO BE PROVIDED TO ANALOG | CAN'T BE PERFORMED BECAUSE THE TRACE LENGTH IS TOO SHORT ON THE OUTER LAYERS AT THE PIN ESCAPES | ADI APPROVAL IS REQUIRED. | OF COMPLIANCE SHALL BE PROVIDED BY VENDOR AT TIME OF SHIPMENT. INSTANCES WHERE TDR TESTING | WITH NON-CONDUCTIVE EPOXY. | (THICKNESS AFTER PLATING) | 1 OZ, 0.0014" MIN | 0.5 OZ, 0.0007" | TBD | FINAL CU | CU CLAD | LAYER | NUMBER | THE FINISHED PCB THICKNESS TO BE: | 1 | 2 | 3 | 4 | TOP | L2_GND | L3_PWR | BOTTOM | NAME | COPPER THICKNESS | (OZ,INCH) | LAMINATION DIAGRAM | 4 LAYER STACKUP | 0.062" +/-10% | DIELECTRIC | THICKNESS (INCH) | ISOLA 370HR/EQUIVALENT | MATERIALS | TOOLING: | FINISH: | NOTES: | MATERIAL: | TESTING: | MISCELLANEOUS:
User.14: L2 GND | 08-      -08
User.15: L3 PWR | 08-      -09
User.32: 10. Manufacturer UL and Date codes on the bottom side in soldermask relief. | 11. Fill vias in these area with conductive epoxy and plate over. | 1. Material: 4 Layer FR4 glass epoxy laminate 1.6mm +/- 10%. material to be RoHS compliant. | 2. Plated thru holes and conductive pattern electroplated with 0.255mm min. thick copper. | 3. Processing tolerence: | 4. Warp and twist within 0.1875mm per 25mm (0.75%) | 5. Dimensions are for the finished part. | 6. SOLDERMASK: liquid Photo Imeagable soldermask over bare copper (SMOBC), | 7. SCREENING: Screen component outlines and nomenclature using indelible white ink on both sides. | 8. Electrically test 100%. | 9. Break all sharp edges 0.35mm Radius max. | Board to be fabricated per IPC-6012A, CLASS 2. | Terminal areas and plated thru holes to be ENIG plated. | colour GREEN both sides using the pattern provided. No mask is permitted on the terminal areas. | Soldermask to etch registration within 0.125mm total. | A. Conductive pattern front to back registration within 0.125mm total. | B. Minimum annual ring surrounding holes 0.05mm. | C. Finished conductive pattern to be within 0.05mm of true size. | D. Minimumfeature size 0.2mm | E. Minimum air gap 0.12mm | Nomenclature shall be legible. Screen to etch registration within 0.15mm total. | FABRICATION NOTES: | SEE NOTE 11 | 1 | FABRICATION | 09-047203-01 | A
User.33: FIGURE | SIZE | 10.0 | 31.0 | 45.0 | 50.0 | 60.0 | 63.0 | 85.0 | 160.0 | DRILL CHART: TOP to BOTTOM | FINISHED HOLES IN MILS | PLATED | NON-PLATED | QTY | 611 | 6 | 82 | 1 | 4 | 17 | 10 | 2 | 8 | TOLERANCE/NOTES
